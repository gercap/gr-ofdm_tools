<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>audio_iq_modulator</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Audio IQ modulator</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>gain</value></param>
<param><key>freq</key><value>carrier</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>gain</value></param>
<param><key>freq</key><value>carrier</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>label</key><value>Audio Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>24e3</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>carrier</value></param>
<param><key>label</key><value>Audio Carrier (Tone)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>label</key><value>iq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>audio</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

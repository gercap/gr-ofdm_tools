<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>local_hw_gateway</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>a1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>a2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>av</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>samp_rate/decim_1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fragments_per_fft</value></param>
<param><key>value</key><value>int(math.ceil((nfft*2.0+2.0)/max_tu))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_tu</value></param>
<param><key>value</key><value>1472*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>freq_offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>value</key><value>ppm</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>precision</value></param>
<param><key>value</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>32bit FFT (or 16b)</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>precision</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>req_mtu</value></param>
<param><key>value</key><value>nfft*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sr</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sub_tune</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>tune_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>103e6</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>10</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>5</value></param>
<param><key>freq</key><value>-250000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>3</value></param>
<param><key>freq</key><value>300000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>decim_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>quad_rate</key><value>samp_rate/decim_1</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>samp_rate/8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_dev</key><value>75e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_1/decim_2</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_1/decim_2</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>max_tu</value></param>
<param><key>port</key><value>str(udp_port)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>max_tu</value></param>
<param><key>port</key><value>str(udp_port)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>max_tu</value></param>
<param><key>port</key><value>str(9999)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>500</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>decim_filter1</value></param>
<param><key>center_freq</key><value>samp_rate/2</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,samp_rate,(samp_rate/2)*(7.0/8),10e3,60)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>decim_filter1_0</value></param>
<param><key>center_freq</key><value>-samp_rate/2</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,samp_rate,samp_rate/2,10e3,60)</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_1_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,samp_rate/decim_1/decim_2,15e3,05e3,60)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>-100e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_0</value></param>
<param><key>center_freq</key><value>tune_freq-sub_tune</value></param>
<param><key>decim</key><value>decim_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,samp_rate,80e3,20e3,50)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_1</value></param>
<param><key>center_freq</key><value>-samp_rate/2.0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,samp_rate,(samp_rate/2)*(7.0/8),10e3,60)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>samp_rate/16</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>60e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nfft</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2048*2)</value></param>
</block>
<block>
<key>ofdm_tools_local_worker</key>
<param><key>id</key><value>ofdm_tools_local_worker_0</value></param>
<param><key>data_precision</key><value>precision</value></param>
<param><key>average</key><value>av</value></param>
<param><key>fft_len</key><value>nfft</value></param>
<param><key>max_tu</key><value>max_tu</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>ofdm_tools_remote_client_qt</key>
<param><key>id</key><value>ofdm_tools_remote_client_qt_0</value></param>
<param><key>precision</key><value>precision</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hold_max</key><value>False</value></param>
<param><key>l</key><value>Complex PSD Plot</value></param>
<param><key>reset_max</key><value>False</value></param>
<param><key>sample_rate</key><value>sr</value></param>
<param><key>axes</key><value>str(axes)</value></param>
<param><key>tune_freq</key><value>tune_freq</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>ppm_corr</value></param>
<param><key>freq0</key><value>tune_freq+offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>remote=tcp://127.0.0.1:1234,soapy=0,driver=remote,remote:driver=rtlsdr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>ppm_corr</value></param>
<param><key>freq0</key><value>tune_freq+offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>ppm_corr</value></param>
<param><key>freq0</key><value>tune_freq+offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>'rtl_tcp=127.0.0.1:1234'</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>35</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_address</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"0.0.0.0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sr</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(1.2e6)</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>Main</value></param>
<param><key>label1</key><value>L</value></param>
<param><key>label2</key><value>R</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_port</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8888</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>port</key><value>7658</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://0.0.0.0:5005</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>fft_filter_xxx_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>ofdm_tools_remote_client_qt_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ofdm_tools_local_worker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decim_filter1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decim_filter1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_tools_local_worker_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ofdm_tools_local_worker_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>decim_filter1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>decim_filter1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>ofdm_tools_local_worker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

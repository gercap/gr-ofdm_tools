<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>qam_simple_modem</value></param>
<param><key>author</key><value>germano capela</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>QAM Modem</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.qam_16()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.qam_16()[1]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_4()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_4()[1]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_delay</value></param>
<param><key>value</key><value>1+(taps_per_filt-1)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_per_filt</value></param>
<param><key>value</key><value>len(tx_rrc_taps)/nfilts</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>len_key</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>constel.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_key</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>comment</key><value>Tagged Stream to PDU block up ahead needs packed bytes</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_key2</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>modulated</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>sps</value></param>
<param><key>lengthtagname</key><value>len_key</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>comment</key><value>Append header to payload</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengthtagname</key><value>len_key</value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>len_key2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constel</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>demod_symbols</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>demod_symbols</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>alias</key><value>burst_shaper0</value></param>
<param><key>insert_phasing</key><value>True</value></param>
<param><key>length_tag_name</key><value>len_key</value></param>
<param><key>post_padding</key><value>filt_delay</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>firdes.window(firdes.WIN_HANN, 20, 0)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>constel.points()</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_0</value></param>
<param><key>access_code</key><value>digital.packet_utils.default_access_code</value></param>
<param><key>comment</key><value>Correlates with access code to extract the payload.</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>len_key2</value></param>
<param><key>threshold</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0_0</value></param>
<param><key>w</key><value>6.28/200.0</value></param>
<param><key>order</key><value>constel.arity()</value></param>
</block>
<block>
<key>digital_lms_dd_equalizer_cc</key>
<param><key>id</key><value>digital_lms_dd_equalizer_cc_0</value></param>
<param><key>cnst</key><value>constel</value></param>
<param><key>mu</key><value>.01</value></param>
<param><key>num_taps</key><value>8</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_1</value></param>
<param><key>map</key><value>constel.pre_diff_code()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/400.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_protocol_formatter_bb</key>
<param><key>id</key><value>digital_protocol_formatter_bb_0</value></param>
<param><key>comment</key><value>Generate header</value></param>
<param><key>format</key><value>hdr_format</value></param>
<param><key>len_tag_key</key><value>len_key</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>eb</value></param>
<param><key>label</key><value>Filter EB</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>comment</key><value>Header format definition</value></param>
<param><key>label</key><value>Header Formatter</value></param>
<param><key>value</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pdus</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>pdus</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pdus_in</value></param>
<param><key>label</key><value>pdus</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrate</key><value>sps</value></param>
<param><key>samp_delay</key><value>filt_delay</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>digital_protocol_formatter_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>digital_map_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>pdus</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0_0</source_block_id><sink_block_id>digital_lms_dd_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>demod_symbols</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdus_in</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>remote_monitor</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>av</value></param>
<param><key>value</key><value>0.8</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>axes</value></param>
<param><key>value</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Axes</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>hold_max</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>1,4,1,1</value></param>
<param><key>label</key><value>Hold Reset</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_mtu</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Freq Offset</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>35</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>PPM</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>precision</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>32bit FFT (or 16b)</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>0,1,1,2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>reset_max</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Max Reset</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1800000</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sub_tune</value></param>
<param><key>value</key><value>tune_freq</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>100e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Tunning Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>100e6</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>Tuning Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>2000e6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>max_mtu</value></param>
<param><key>port</key><value>str(udp_port)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>max_mtu</value></param>
<param><key>port</key><value>str(tcp_port)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>max_mtu</value></param>
<param><key>port</key><value>str(9999)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>ofdm_tools_remote_client_qt</key>
<param><key>id</key><value>ofdm_tools_remote_client_qt_0_0</value></param>
<param><key>precision</key><value>precision</value></param>
<param><key>gui_hint</key><value>3,0,1,5</value></param>
<param><key>hold_max</key><value>hold_max</value></param>
<param><key>l</key><value>Complex PSD Plot</value></param>
<param><key>reset_max</key><value>reset_max</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>axes</key><value>str(axes)</value></param>
<param><key>tune_freq</key><value>tune_freq</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_address</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>Main</value></param>
<param><key>label1</key><value>L</value></param>
<param><key>label2</key><value>R</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tcp_port</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9999</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_port</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8888</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client0</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_bb_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>bb_gain</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client0_0</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_samp_rate</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>samp_rate</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client1</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_if_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>if_gain</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client2</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_rf_gain</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>rf_gain</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client3</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_tune_freq</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>tune_freq</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client4</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_av</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>av</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client4_0</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_ppm_corr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>ppm</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client4_0_0</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_offset</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>offset</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client4_0_1</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_precision</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>precision</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client5</value></param>
<param><key>addr</key><value>server_address</value></param>
<param><key>callback</key><value>set_rate</value></param>
<param><key>port</key><value>7658</value></param>
<param><key>variable</key><value>rate</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5005</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>ofdm_tools_remote_client_qt_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>ofdm_tools_remote_client_qt_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>ofdm_tools_remote_client_qt_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ascii_sink</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>av</value></param>
<param><key>value</key><value>0.8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>height</value></param>
<param><key>value</key><value>def_height</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sr</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>250e3</value></param>
<param><key>step</key><value>250e3</value></param>
<param><key>stop</key><value>8e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>97e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>28e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>1800e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>width</value></param>
<param><key>value</key><value>def_width</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>8888</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>def_height</value></param>
<param><key>short_id</key><value>e</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>def_width</value></param>
<param><key>short_id</key><value>w</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nfft</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8092</value></param>
</block>
<block>
<key>ofdm_tools_ascii_gnuplot</key>
<param><key>id</key><value>ofdm_tools_ascii_gnuplot_0</value></param>
<param><key>average</key><value>av</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>nfft</value></param>
<param><key>height</key><value>height</value></param>
<param><key>rate</key><value>5</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
<param><key>tune_freq</key><value>tune_freq</value></param>
<param><key>width</key><value>width</value></param>
</block>
<block>
<key>ofdm_tools_ascii_plot</key>
<param><key>id</key><value>ofdm_tools_ascii_plot_0</value></param>
<param><key>average</key><value>av</value></param>
<param><key>fft_len</key><value>int(nfft)</value></param>
<param><key>height</key><value>height</value></param>
<param><key>rate</key><value>5</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
<param><key>tune_freq</key><value>tune_freq</value></param>
<param><key>width</key><value>width</value></param>
</block>
<block>
<key>ofdm_tools_ascii_proxy</key>
<param><key>id</key><value>ofdm_tools_ascii_proxy_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>average</key><value>av</value></param>
<param><key>fft_len</key><value>int(nfft)</value></param>
<param><key>height</key><value>height</value></param>
<param><key>rate</key><value>5</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
<param><key>tune_freq</key><value>tune_freq</value></param>
<param><key>width</key><value>width</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>freq0</key><value>tune_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fftsize</key><value>nfft</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sr</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(1e6)</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>ofdm_tools_ascii_plot_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>pkt_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>ofdm_tools_ascii_gnuplot_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>ofdm_tools_ascii_plot_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>ofdm_tools_ascii_proxy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

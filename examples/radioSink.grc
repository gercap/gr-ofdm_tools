<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radioC</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod</value></param>
<param><key>value</key><value>digital.constellation_qpsk() </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>digital.qam.qam_constellation(16,True,'none',False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npts</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>ofdm_tools_payload_sink</key>
<param><key>id</key><value>ofdm_tools_payload_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>callback</key><value>'change for your callback here'</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>8888</value></param>
<param><key>server</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe_var</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>probe_avg_mag2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>qt_label</value></param>
<param><key>label</key><value>Output Level</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>probe_var</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe_papr</value></param>
<param><key>value</key><value>1e-9</value></param>
<param><key>block_id</key><value>papr_sink</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>clipping_factor</value></param>
<param><key>value</key><value>5</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>5</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>ofdm_tools_payload_source</key>
<param><key>id</key><value>payload_source</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ggc/Dropbox/_IST MEEC-TEL/_TESE DE MESTRADO/GNU_RADIO/code/test_msg.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>125000</value></param>
<param><key>start</key><value>1e3</value></param>
<param><key>stop</key><value>8e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>100</value></param>
<param><key>start</key><value>50</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>step</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_rxpath</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>Rx Bytes</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>probe_avg_mag2</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>8888</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>graph_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>qt_label_0</value></param>
<param><key>label</key><value>PAPR</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>probe_papr</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>msg_in_pdu_0_0_1</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.intern("SC") )</value></param>
<param><key>period</key><value>4000</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>ifn</key><value>tun0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_0</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.make_u8vector(packet_len,1) )</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>msg_in_pdu_0</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.intern("asking for papr measurement") )</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>ofdm_tools_spectrum_sensor</key>
<param><key>id</key><value>ofdm_tools_spectrum_sensor_1</value></param>
<param><key>tune_freq</key><value>97e6</value></param>
<param><key>fft_len</key><value>1024</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>channel_space</key><value>100e3</value></param>
<param><key>search_bw</key><value>80e3</value></param>
<param><key>vect_length</key><value>npts</value></param>
<param><key>method</key><value>'welch'</value></param>
<param><key>thr_leveler</key><value>10</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>msg_in_pdu_0_0</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.intern("PAPR") )</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>ofdm_radio_hier</key>
<param><key>id</key><value>ofdm_radio_hier_0</value></param>
<param><key>pilot_carriers</key><value>((-40, -14, 13, 39),)</value></param>
<param><key>pilot_symbols</key><value>((1, 1, 1, -1,),)</value></param>
<param><key>occupied_carriers</key><value>([-54, -53, -52, -51, -50, -49, -48, -47, -46, -45, -44, -43, -42, -41, -39, -38, -37, -36, -35, -34, -33, -32, -31, -30, -29, -28, -27, -26, -25, -24, -23, -22, -21, -20, -19, -18, -17, -16, -15, -13, -12, -11, -10, -9, -8, -7, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53],)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync_word1</key><value>[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, 1.42, 0.0, 1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, 1.42, 0.0, 1.42, 0.0, 1.42, 0.0, 1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, 1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, 1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, 1.42, 0.0, 1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, 1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, -1.42, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0]</value></param>
<param><key>sync_word2</key><value>[0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j]</value></param>
<param><key>payload_mod</key><value>'qam16'</value></param>
<param><key>scramble_mode</key><value>0</value></param>
<param><key>crc_mode</key><value>1</value></param>
<param><key>clipper_mode</key><value>1</value></param>
<param><key>clipping_factor</key><value>clipping_factor</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>freq0</key><value>97e6</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>25</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>npts</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
</block>
<block>
<key>ofdm_tools_papr_sink</key>
<param><key>id</key><value>papr_sink</value></param>
<param><key>block_len</key><value>1024</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle_in_out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>payload_source</source_block_id><sink_block_id>ofdm_radio_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_radio_hier_0</source_block_id><sink_block_id>ofdm_tools_payload_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_radio_hier_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_radio_hier_0</source_block_id><sink_block_id>blocks_tag_debug_rxpath</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_radio_hier_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_tools_spectrum_sensor_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>PDU spect_msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ofdm_radio_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>ofdm_radio_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_radio_hier_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle_in_out</source_block_id><sink_block_id>probe_avg_mag2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle_in_out</source_block_id><sink_block_id>graph_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_radio_hier_0</source_block_id><sink_block_id>throttle_in_out</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle_in_out</source_block_id><sink_block_id>ofdm_radio_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>msg_in_pdu_0_0_1</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>strobe</source_key><sink_key>PDU from_cogeng</sink_key></connection>
<connection><source_block_id>msg_in_pdu_0_0</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>strobe</source_key><sink_key>PDU from_cogeng</sink_key></connection>
<connection><source_block_id>msg_in_pdu_0</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>strobe</source_key><sink_key>PDU from_cogeng</sink_key></connection>
<connection><source_block_id>throttle_in_out</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>throttle_in_out</source_block_id><sink_block_id>papr_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

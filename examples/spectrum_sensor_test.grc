<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectrum_sensor_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>msg_in_pdu</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.make_u8vector(10,3) )</value></param>
<param><key>period</key><value>2000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>msg_in_pdu_0_0_1</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.intern("SC") )</value></param>
<param><key>period</key><value>4000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>97e6</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>stop</key><value>1800e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>fc</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>25</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>msg_in_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.intern("testing") )</value></param>
<param><key>period</key><value>2000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>msg_in_pdu_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.intern("PAPR") )</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vlen</value></param>
</block>
<block>
<key>ofdm_tools_spectrum_sensor</key>
<param><key>id</key><value>ofdm_tools_spectrum_sensor_1</value></param>
<param><key>tune_freq</key><value>fc</value></param>
<param><key>fft_len</key><value>4096</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
<param><key>channel_space</key><value>100e3</value></param>
<param><key>search_bw</key><value>50e3</value></param>
<param><key>vect_length</key><value>vlen</value></param>
</block>
<connection><source_block_id>ofdm_tools_spectrum_sensor_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>PDU spect_msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>msg_in_pdu_0_0_1</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>strobe</source_key><sink_key>PDU from_cogeng</sink_key></connection>
<connection><source_block_id>msg_in_pdu_0_0</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>strobe</source_key><sink_key>PDU from_cogeng</sink_key></connection>
<connection><source_block_id>msg_in_pdu_0</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>strobe</source_key><sink_key>PDU from_cogeng</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>ofdm_tools_spectrum_sensor_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>local_hw_gateway</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>a1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>a2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>aud_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>bb_rate/decim_2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>av</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>samp_rate/decim_1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fragments_per_fft</value></param>
<param><key>value</key><value>int(math.ceil((nfft*4.0+2.0)/max_tu))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_tu</value></param>
<param><key>value</key><value>1472*20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>freq_offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pkt_len</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>value</key><value>ppm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>precision</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>req_mtu</value></param>
<param><key>value</key><value>nfft*4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rf_gain_start</value></param>
<param><key>block_id</key><value>rf_source</value></param>
<param><key>function_name</key><value>get_gain_range().start</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.001</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rf_gain_step</value></param>
<param><key>block_id</key><value>rf_source</value></param>
<param><key>function_name</key><value>get_gain_range().step</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.001</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rf_gain_stop</value></param>
<param><key>block_id</key><value>rf_source</value></param>
<param><key>function_name</key><value>get_gain_range().stop</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sr</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>103e6</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>a1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-250000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>a1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>300000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>decim_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>quad_rate</key><value>samp_rate/decim_1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arg</value></param>
<param><key>label</key><value>osmocom device arg</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_1/decim_2</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>4096</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>4096</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>pkt_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_1_0</value></param>
<param><key>decim</key><value>decim_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,samp_rate,80e3,20e3,50)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_1_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,aud_rate,4e3,3e3,60)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>100e6-tune_freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_1</value></param>
<param><key>center_freq</key><value>-samp_rate/2.0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,samp_rate,(samp_rate/2)*(7.0/8),10e3,60)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nfft</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2048)</value></param>
</block>
<block>
<key>ofdm_tools_local_worker</key>
<param><key>id</key><value>ofdm_tools_local_worker_0</value></param>
<param><key>data_precision</key><value>precision</value></param>
<param><key>average</key><value>av</value></param>
<param><key>fft_len</key><value>nfft</value></param>
<param><key>max_tu</key><value>max_tu</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>ofdm_tools_remote_client_qt</key>
<param><key>id</key><value>ofdm_tools_remote_client_qt_0</value></param>
<param><key>precision</key><value>precision</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hold_max</key><value>False</value></param>
<param><key>l</key><value>Complex PSD Plot</value></param>
<param><key>reset_max</key><value>False</value></param>
<param><key>sample_rate</key><value>sr</value></param>
<param><key>axes</key><value>True</value></param>
<param><key>tune_freq</key><value>tune_freq</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>rf_source</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>corr0</key><value>ppm_corr</value></param>
<param><key>freq0</key><value>tune_freq+offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>comment</key><value>remote=tcp://127.0.0.1:1234,soapy=0,driver=remote,remote:driver=rtlsdr
plutosdr=0</value></param>
<param><key>args</key><value>arg</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sr</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>int(2.4e6)</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_g721_encode_sb</key>
<param><key>id</key><value>vocoder_g721_encode_sb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server</value></param>
<param><key>addr</key><value>"0.0.0.0"</value></param>
<param><key>port</key><value>7658</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>"tcp://0.0.0.0:"+str(zmq_port)</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_1</value></param>
<param><key>address</key><value>"tcp://0.0.0.0:"+str(9999)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5005</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_1</value></param>
<param><key>address</key><value>tcp://127.0.0.1:9999</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zmq_port</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5005</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>fft_filter_xxx_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0_0</source_block_id><sink_block_id>vocoder_g721_encode_sb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>vocoder_g721_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_1</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1_0_0</source_block_id><sink_block_id>blocks_float_to_short_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_tools_local_worker_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>rf_source</source_block_id><sink_block_id>fft_filter_xxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rf_source</source_block_id><sink_block_id>ofdm_tools_local_worker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0</source_block_id><sink_block_id>blocks_short_to_float_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_encode_sb_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>ofdm_tools_remote_client_qt_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
